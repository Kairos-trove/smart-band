# Keil uVision project IIC.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: IIC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  c misc: --no-multibyte-chars
  c include: ..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\IIC;..\HARDWARE\BUZZER;..\HARDWARE\DS18B20;..\HARDWARE\MPU6050;..\SYSTEM\timer;..\HARDWARE\OLED;..\HARDWARE\DHT11;..\HARDWARE\DS1302;..\HARDWARE\STEP_COUNTER
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: stm32f10x_it.c system_stm32f10x.c stm32f10x_conf.h main.c
  group HARDWARE
    ../HARDWARE/IIC/: myiic.c max30102.c algorithm.c
    ../HARDWARE/BUZZER/: Buzzer.c
    ../HARDWARE/DS18B20/: ds18b20.c
    ../HARDWARE/DHT11/: dht11.c
    ../HARDWARE/DS1302/: ds1302.c
    ../HARDWARE/MPU6050/: MPU6050_Reg.h
    ../HARDWARE/OLED/: OELD_Data.c OLED.c
    ../HARDWARE/STEP_COUNTER/: STEP_COUNTER.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/timer/: timer.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_i2c.c stm32f10x_tim.c
software components: CMSIS:CORE 5.1.2
